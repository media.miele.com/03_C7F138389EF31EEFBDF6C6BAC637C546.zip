Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 9acb0384-1b20-4d8d-84bf-48cce8aeb052, NumberOfSaves: 1]
File name: 0001
Time: 2025-02-27T12:35:24+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10869040_PAC_DA6698W_EDST:28669850_PAC_10869040_DA6698W_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 898 mm; Height: 85 mm; Depth: 500 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28669850_PAC_10869040_DA6698W_EDST; sets with these values: 2
